* Circuit, read from the shapes
.subckt gf180mcu_fd_sc_mcu7t5v0__addf_1 A B CI CO S VDD VNW VSS
XM1 VSS n1 S VSUBS nfet_05v0 w=0.71u l=0.6u
XM2 n2 A VSS VSUBS nfet_05v0 w=0.38u l=0.6u
XM3 n3 B n2 VSUBS nfet_05v0 w=0.38u l=0.6u
XM4 n1 CI n3 VSUBS nfet_05v0 w=0.38u l=0.6u
XM5 n4 n5 n1 VSUBS nfet_05v0 w=0.38u l=0.6u
XM6 VSS A n4 VSUBS nfet_05v0 w=0.38u l=0.6u
XM7 n4 B VSS VSUBS nfet_05v0 w=0.38u l=0.6u
XM8 VSS CI n4 VSUBS nfet_05v0 w=0.38u l=0.6u
XM9 VSS B n6 VSUBS nfet_05v0 w=0.38u l=0.6u
XM10 n6 A VSS VSUBS nfet_05v0 w=0.38u l=0.6u
XM11 n5 CI n6 VSUBS nfet_05v0 w=0.38u l=0.6u
XM12 n7 B n5 VSUBS nfet_05v0 w=0.38u l=0.6u
XM13 VSS A n7 VSUBS nfet_05v0 w=0.38u l=0.6u
XM14 CO n5 VSS VSUBS nfet_05v0 w=0.815u l=0.6u
XM15 VDD n1 S VNW pfet_05v0 w=1.215u l=0.5u
XM16 n8 A VDD VNW pfet_05v0 w=0.66u l=0.5u
XM17 n9 B n8 VNW pfet_05v0 w=0.66u l=0.5u
XM18 n1 CI n9 VNW pfet_05v0 w=0.66u l=0.5u
XM19 n10 n5 n1 VNW pfet_05v0 w=0.66u l=0.5u
XM20 VDD A n10 VNW pfet_05v0 w=0.66u l=0.5u
XM21 n10 B VDD VNW pfet_05v0 w=0.66u l=0.5u
XM22 VDD CI n10 VNW pfet_05v0 w=0.66u l=0.5u
XM23 VDD B n11 VNW pfet_05v0 w=0.7u l=0.5u
XM24 n11 A VDD VNW pfet_05v0 w=0.7u l=0.5u
XM25 n5 CI n11 VNW pfet_05v0 w=0.7u l=0.5u
XM26 n12 B n5 VNW pfet_05v0 w=0.7u l=0.5u
XM27 VDD A n12 VNW pfet_05v0 w=0.7u l=0.5u
XM28 CO n5 VDD VNW pfet_05v0 w=1.215u l=0.5u
.ends

# Layout, gdstk code
import gdstk
lib = gdstk.Library(unit=1e-6, precision=1e-09)
def R(c, l, rs):  # rectangles x0, y0, x1, y1
    for r in rs: c.add(gdstk.rectangle(r[:2], r[2:], *l))
def P(c, l, *ps):  # polygons
    for p in ps: c.add(gdstk.Polygon(p, *l))
boundary = (0, 0)
nwell = (21, 0)
comp = (22, 0)
poly2 = (30, 0)
pplus = (31, 0)
nplus = (32, 0)
contact = (33, 0)
metal1 = (34, 0)
dualgate = (55, 0)
v5_xtor = (112, 1)
lvpwell = (204, 0)

gf180mcu_fd_sc_mcu7t5v0_ = lib.new_cell('gf180mcu_fd_sc_mcu7t5v0__addf_1')
R(gf180mcu_fd_sc_mcu7t5v0_, boundary, [(0,0,18.48,3.92)])
R(gf180mcu_fd_sc_mcu7t5v0_, nwell, [(-0.43,1.76,18.91,4.35)])
P(gf180mcu_fd_sc_mcu7t5v0_, comp, [(0.28,2.36),(0.28,3.575),(1.66,3.575),(1.66,3.14),(6.78,3.14),(6.78,3.3),(7.14,3.3),(7.14,3.14),(9.4,3.14),(9.4,2.48),(1.62,2.48),(1.62,2.36)],
  [(0.18,0.45),(0.18,1.16),(9.6,1.16),(9.6,0.78),(7.14,0.78),(7.14,0.62),(6.78,0.62),(6.78,0.78),(1.66,0.78),(1.66,0.45)],
  [(10.06,2.36),(10.06,3.06),(11.3,3.06),(11.3,3.3),(11.66,3.3),(11.66,3.06),(16.38,3.06),(16.38,3.575),(17.76,3.575),(17.76,2.36)],
  [(16.38,0.345),(16.38,0.78),(13.22,0.78),(13.22,0.62),(12.86,0.62),(12.86,0.78),(11.66,0.78),(11.66,0.62),(11.3,0.62),(11.3,0.78),(9.96,0.78),(9.96,1.16),(17.86,1.16),(17.86,0.345)])
P(gf180mcu_fd_sc_mcu7t5v0_, poly2, [(0.62,0.23),(0.62,1.44),(0.72,1.44),(0.72,3.8),(1.22,3.8),(1.22,0.23)],
  [(3.64,0.56),(3.64,1.44),(3.74,1.44),(3.74,3.36),(4.24,3.36),(4.24,0.56)],
  [(4.76,0.56),(4.76,1.44),(4.86,1.44),(4.86,3.36),(5.36,3.36),(5.36,0.56)],
  [(8.56,0.56),(8.56,1.555),(8.46,1.555),(8.46,3.36),(8.96,3.36),(8.96,1.505),(9.16,1.505),(9.16,0.56)],
  [(13.52,0.56),(13.52,3.28),(14.02,3.28),(14.02,1.44),(14.12,1.44),(14.12,0.56)],
  [(2.8,0.56),(2.8,1.44),(2.9,1.44),(2.9,3.8),(15.14,3.8),(15.14,1.44),(15.24,1.44),(15.24,0.56),(14.64,0.56),(14.64,3.6),(11,3.6),(11,0.56),(10.4,0.56),(10.4,1.44),(10.5,1.44),(10.5,3.6),(7.94,3.6),(7.94,1.44),(8.04,1.44),(8.04,0.56),(7.44,0.56),(7.44,3.6),(3.4,3.6),(3.4,0.56)],
  [(1.96,0.12),(1.96,1.44),(2.06,1.44),(2.06,3.36),(2.56,3.36),(2.56,0.32),(5.88,0.32),(5.88,1.44),(5.98,1.44),(5.98,3.36),(6.48,3.36),(6.48,0.32),(11.96,0.32),(11.96,3.28),(12.46,3.28),(12.46,1.44),(12.56,1.44),(12.56,0.32),(15.48,0.32),(15.48,3.28),(15.98,3.28),(15.98,1.44),(16.08,1.44),(16.08,0.12)],
  [(16.82,0.12),(16.82,3.8),(17.32,3.8),(17.32,1.44),(17.42,1.44),(17.42,0.12)])
R(gf180mcu_fd_sc_mcu7t5v0_, pplus, [(-0.2,1.76,18.68,4.12)])
R(gf180mcu_fd_sc_mcu7t5v0_, nplus, [(-0.2,-0.2,18.68,1.76)])
R(gf180mcu_fd_sc_mcu7t5v0_, contact, [(16.45,0.485,16.67,0.705), (1.37,0.59,1.59,0.81), (6.85,0.69,7.07,0.91), (11.37,0.69,11.59,0.91), (12.93,0.69,13.15,0.91), (10.03,0.85,10.25,1.07), (14.27,0.85,14.49,1.07), (17.57,0.85,17.79,1.07), (0.25,0.865,0.47,1.085), (9.31,0.865,9.53,1.085), (4.39,0.87,4.61,1.09), (5.51,0.87,5.73,1.09), (8.19,0.87,8.41,1.09), (16.89,1.34,17.11,1.56), (0.93,1.405,1.15,1.625), (13.59,1.46,13.81,1.68), (3.95,1.625,4.17,1.845), (8.595,1.625,8.815,1.845), (2.27,1.835,2.49,2.055), (14.85,1.85,15.07,2.07), (0.93,1.88,1.15,2.1), (5.07,2.09,5.29,2.31), (14.17,2.445,14.39,2.665), (10.13,2.55,10.35,2.77), (12.61,2.55,12.83,2.77), (13.15,2.55,13.37,2.77), (4.39,2.565,4.61,2.785), (5.61,2.565,5.83,2.785), (8.09,2.565,8.31,2.785), (16.45,2.58,16.67,2.8), (17.47,2.58,17.69,2.8), (0.35,2.62,0.57,2.84), (9.11,2.765,9.33,2.985), (6.85,3.01,7.07,3.23), (11.37,3.01,11.59,3.23), (16.45,3.05,16.67,3.27), (17.47,3.05,17.69,3.27), (0.35,3.09,0.57,3.31), (1.37,3.22,1.59,3.44)])
R(gf180mcu_fd_sc_mcu7t5v0_, metal1, [(0.14,0.61,0.575,3.37), (17.45,0.79,17.83,3.37), (1.615,1.77,3.47,2.15), (14.64,1.795,17.07,2.15), (10.07,2.545,13.43,2.775)])
P(gf180mcu_fd_sc_mcu7t5v0_, metal1, [(4.385,0.81),(4.385,1.16),(0.925,1.16),(0.925,2.79),(4.71,2.79),(4.71,2.56),(1.155,2.56),(1.155,1.39),(4.615,1.39),(4.615,0.81)],
  [(5.55,2.545),(5.55,2.845),(5.89,2.845),(5.89,2.775),(8.03,2.775),(8.03,2.845),(8.37,2.845),(8.37,2.545)],
  [(5.505,0.81),(5.505,1.375),(8.415,1.375),(8.415,0.81),(8.185,0.81),(8.185,1.145),(5.735,1.145),(5.735,0.81)],
  [(11.88,0.68),(11.88,1.145),(10.255,1.145),(10.255,0.77),(10.025,0.77),(10.025,1.375),(12.11,1.375),(12.11,0.915),(13.21,0.915),(13.21,0.68)],
  [(13.54,0.55),(13.54,1.2),(12.34,1.2),(12.34,1.62),(3.89,1.62),(3.89,1.85),(13.91,1.85),(13.91,0.55)],
  [(14.17,0.75),(14.17,2.08),(5.01,2.08),(5.01,2.315),(14.165,2.315),(14.165,2.765),(14.4,2.765),(14.4,1.565),(17.2,1.565),(17.2,1.335),(14.495,1.335),(14.495,0.75)],
  [(0,-0.3),(0,0.3),(1.365,0.3),(1.365,0.87),(1.595,0.87),(1.595,0.3),(6.79,0.3),(6.79,0.915),(7.13,0.915),(7.13,0.3),(9.25,0.3),(9.25,1.09),(9.59,1.09),(9.59,0.3),(11.31,0.3),(11.31,0.915),(11.65,0.915),(11.65,0.3),(16.445,0.3),(16.445,0.765),(16.675,0.765),(16.675,0.3),(18.48,0.3),(18.48,-0.3)],
  [(16.445,2.48),(16.445,3.62),(11.65,3.62),(11.65,3.005),(11.31,3.005),(11.31,3.62),(9.335,3.62),(9.335,2.705),(9.105,2.705),(9.105,3.62),(7.13,3.62),(7.13,3.005),(6.79,3.005),(6.79,3.62),(1.595,3.62),(1.595,3.04),(1.365,3.04),(1.365,3.62),(0,3.62),(0,4.22),(18.48,4.22),(18.48,3.62),(16.675,3.62),(16.675,2.48)])
R(gf180mcu_fd_sc_mcu7t5v0_, dualgate, [(-0.28,-0.28,18.76,4.2)])
R(gf180mcu_fd_sc_mcu7t5v0_, v5_xtor, [(0,0,18.48,3.92)])
R(gf180mcu_fd_sc_mcu7t5v0_, lvpwell, [(-0.43,-0.43,18.91,1.76)])
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('B', (15.96,1.96), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('CI', (12.6,1.4), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('CO', (17.64,1.96), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('S', (0.28,1.96), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VDD', (9.24,3.92), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VSS', (9.24,0), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('A', (2.52,1.96), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Vendor GLOBALFOUNDRIES', (0,2), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Product GF018hv5v_mcu_sc7', (0,1.5), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Version 2015q2v1', (0,1), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Metric 1.00', (0,0.5), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VNW', (0.345,3.92), layer=21, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VPW', (0.34,-0.085), layer=204, texttype=10))

lib.write_gds('gf180mcu_fd_sc_mcu7t5v0__addf_1.gds')
