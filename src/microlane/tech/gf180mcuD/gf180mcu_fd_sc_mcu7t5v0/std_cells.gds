* Circuit, read from the shapes
.subckt gf180mcu_fd_sc_mcu7t5v0__addh_1 A B CO S VDD VNW VSS
XM1 VSS n1 CO VSUBS nfet_05v0 w=0.815u l=0.6u
XM2 n2 A VSS VSUBS nfet_05v0 w=0.48u l=0.6u
XM3 n1 B n2 VSUBS nfet_05v0 w=0.48u l=0.6u
XM4 n3 B n4 VSUBS nfet_05v0 w=0.42u l=0.6u
XM5 n4 A n3 VSUBS nfet_05v0 w=0.42u l=0.6u
XM6 VSS n1 n4 VSUBS nfet_05v0 w=0.42u l=0.6u
XM7 S n3 VSS VSUBS nfet_05v0 w=0.815u l=0.6u
XM8 VDD n1 CO VNW pfet_05v0 w=1.22u l=0.5u
XM9 n1 A VDD VNW pfet_05v0 w=0.635u l=0.5u
XM10 VDD B n1 VNW pfet_05v0 w=0.635u l=0.5u
XM11 n5 B VDD VNW pfet_05v0 w=0.635u l=0.5u
XM12 n3 A n5 VNW pfet_05v0 w=0.635u l=0.5u
XM13 VDD n1 n3 VNW pfet_05v0 w=0.635u l=0.5u
XM14 S n3 VDD VNW pfet_05v0 w=1.22u l=0.5u
.ends

# Layout, gdstk code
import gdstk
lib = gdstk.Library(unit=1e-6, precision=1e-09)
def R(c, l, rs):  # rectangles x0, y0, x1, y1
    for r in rs: c.add(gdstk.rectangle(r[:2], r[2:], *l))
def A(c, l, x, y, w, h, nx, ny, dx, dy):  # array of equal rectangles
    R(c, l, [(x+i*dx, y+j*dy, x+i*dx+w, y+j*dy+h) for i in range(nx) for j in range(ny)])
def P(c, l, *ps):  # polygons
    for p in ps: c.add(gdstk.Polygon(p, *l))
boundary = (0, 0)
nwell = (21, 0)
comp = (22, 0)
poly2 = (30, 0)
pplus = (31, 0)
nplus = (32, 0)
contact = (33, 0)
metal1 = (34, 0)
dualgate = (55, 0)
v5_xtor = (112, 1)
lvpwell = (204, 0)

gf180mcu_fd_sc_mcu7t5v0_ = lib.new_cell('gf180mcu_fd_sc_mcu7t5v0__addh_1')
R(gf180mcu_fd_sc_mcu7t5v0_, boundary, [(0,0,10.08,3.92)])
P(gf180mcu_fd_sc_mcu7t5v0_, nwell, [(-0.43,1.76),(-0.43,4.35),(10.51,4.35),(10.51,1.76),(6.71,1.76),(6.71,1.885),(5.19,1.885),(5.19,1.76)])
P(gf180mcu_fd_sc_mcu7t5v0_, comp, [(0.18,0.345),(0.18,1.16),(3.86,1.16),(3.86,0.68),(1.68,0.68),(1.68,0.345)],
  [(0.28,2.36),(0.28,3.58),(3.94,3.58),(3.94,2.945),(1.62,2.945),(1.62,2.36)],
  [(8.36,2.36),(8.36,2.945),(4.32,2.945),(4.32,3.58),(9.7,3.58),(9.7,2.36)],
  [(8.36,0.345),(8.36,0.74),(4.22,0.74),(4.22,1.16),(5.56,1.16),(5.56,1.285),(5.92,1.285),(5.92,1.16),(9.8,1.16),(9.8,0.345)])
P(gf180mcu_fd_sc_mcu7t5v0_, poly2, [(0.62,0.12),(0.62,1.38),(0.72,1.38),(0.72,3.8),(1.22,3.8),(1.22,0.12)],
  [(1.98,0.46),(1.98,3.8),(2.48,3.8),(2.48,2.335),(2.58,2.335),(2.58,0.46)],
  [(2.82,0.46),(2.82,2.14),(3,2.14),(3,3.8),(3.5,3.8),(3.5,2.14),(4.76,2.14),(4.76,3.8),(5.26,3.8),(5.26,0.52),(4.66,0.52),(4.66,1.78),(3.42,1.78),(3.42,0.46)],
  [(6.22,0.52),(6.22,1.86),(5.8,1.86),(5.8,3.8),(6.3,3.8),(6.3,2.22),(6.82,2.22),(6.82,0.52)],
  [(7.46,0.52),(7.46,1.44),(7.56,1.44),(7.56,3.8),(8.06,3.8),(8.06,0.52)],
  [(8.76,0.12),(8.76,3.8),(9.26,3.8),(9.26,1.44),(9.36,1.44),(9.36,0.12)])
P(gf180mcu_fd_sc_mcu7t5v0_, pplus, [(-0.2,1.76),(-0.2,4.12),(10.28,4.12),(10.28,1.76),(6.71,1.76),(6.71,1.885),(5.19,1.885),(5.19,1.76)])
P(gf180mcu_fd_sc_mcu7t5v0_, nplus, [(-0.2,-0.2),(-0.2,1.76),(5.19,1.76),(5.19,1.885),(6.71,1.885),(6.71,1.76),(10.28,1.76),(10.28,-0.2)])
A(gf180mcu_fd_sc_mcu7t5v0_, contact, 3.805, 1.85, 0.22, 0.22, 3, 1, 0.47, 0)
R(gf180mcu_fd_sc_mcu7t5v0_, contact, [(1.37,0.415,1.59,0.635), (0.25,0.81,0.47,1.03), (4.29,0.81,4.51,1.03), (6.97,0.81,7.19,1.03), (8.21,0.81,8.43,1.03), (9.51,0.81,9.73,1.03), (3.57,0.87,3.79,1.09), (5.63,0.995,5.85,1.215), (0.93,1.745,1.15,1.965), (7.63,1.745,7.85,1.965), (2.29,1.85,2.51,2.07), (5.87,1.93,6.09,2.15), (8.83,1.97,9.05,2.19), (0.35,2.58,0.57,2.8), (9.41,2.58,9.63,2.8), (7.07,3.015,7.29,3.235), (0.35,3.05,0.57,3.27), (9.41,3.05,9.63,3.27), (2.63,3.105,2.85,3.325), (8.21,3.135,8.43,3.355), (1.37,3.29,1.59,3.51), (3.65,3.29,3.87,3.51), (4.39,3.29,4.61,3.51)])
R(gf180mcu_fd_sc_mcu7t5v0_, metal1, [(0.14,0.65,0.575,3.37), (3.725,1.79,5.51,2.135)])
P(gf180mcu_fd_sc_mcu7t5v0_, metal1, [(1.505,1.77),(1.505,2.15),(2.775,2.15),(2.775,2.595),(6.095,2.595),(6.095,1.87),(5.865,1.87),(5.865,2.365),(3.27,2.365),(3.27,1.77)],
  [(4.23,0.53),(4.23,1.035),(4.57,1.035),(4.57,0.76),(6.91,0.76),(6.91,1.035),(7.25,1.035),(7.25,0.53)],
  [(3.475,0.81),(3.475,0.87),(0.925,0.87),(0.925,3),(2.14,3),(2.14,3.33),(3.34,3.33),(3.34,3.055),(6.645,3.055),(6.645,1.97),(7.91,1.97),(7.91,1.74),(6.415,1.74),(6.415,2.825),(3.11,2.825),(3.11,3.1),(2.37,3.1),(2.37,2.77),(1.155,2.77),(1.155,1.1),(3.85,1.1),(3.85,0.81)],
  [(5.57,0.99),(5.57,1.495),(8.14,1.495),(8.14,2.375),(7.12,2.375),(7.12,3.01),(7.01,3.01),(7.01,3.24),(7.35,3.24),(7.35,2.61),(8.37,2.61),(8.37,2.25),(9.055,2.25),(9.055,1.91),(8.37,1.91),(8.37,1.265),(5.91,1.265),(5.91,0.99)],
  [(8.975,0.65),(8.975,1.68),(9.405,1.68),(9.405,3.37),(9.735,3.37),(9.735,0.65)],
  [(0,-0.3),(0,0.3),(1.31,0.3),(1.31,0.64),(1.65,0.64),(1.65,0.3),(8.15,0.3),(8.15,1.035),(8.49,1.035),(8.49,0.3),(10.08,0.3),(10.08,-0.3)],
  [(8.205,3.075),(8.205,3.62),(4.67,3.62),(4.67,3.285),(4.33,3.285),(4.33,3.62),(3.93,3.62),(3.93,3.285),(3.59,3.285),(3.59,3.62),(1.595,3.62),(1.595,3.23),(1.365,3.23),(1.365,3.62),(0,3.62),(0,4.22),(10.08,4.22),(10.08,3.62),(8.435,3.62),(8.435,3.075)])
R(gf180mcu_fd_sc_mcu7t5v0_, dualgate, [(-0.28,-0.28,10.36,4.2)])
R(gf180mcu_fd_sc_mcu7t5v0_, v5_xtor, [(0,0,10.08,3.92)])
P(gf180mcu_fd_sc_mcu7t5v0_, lvpwell, [(-0.43,-0.43),(-0.43,1.76),(5.19,1.76),(5.19,1.885),(6.71,1.885),(6.71,1.76),(10.51,1.76),(10.51,-0.43)])
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('CO', (0.28,1.96), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('S', (9.24,1.4), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VDD', (5.04,3.92), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VSS', (5.04,0), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('A', (3.08,1.96), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('B', (4.76,1.96), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Vendor GLOBALFOUNDRIES', (0,2), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Product GF018hv5v_mcu_sc7', (0,1.5), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Version 2015q2v1', (0,1), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Metric 1.00', (0,0.5), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VNW', (0.345,3.92), layer=21, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VPW', (0.34,-0.085), layer=204, texttype=10))

lib.write_gds('gf180mcu_fd_sc_mcu7t5v0__addh_1.gds')
