* Circuit, read from the shapes
.subckt gf180mcu_fd_sc_mcu7t5v0__icgtp_1 CLK E Q TE VDD VNW VSS
XM1 VSS TE n1 VSUBS nfet_05v0 w=0.395u l=0.6u
XM2 n1 E VSS VSUBS nfet_05v0 w=0.395u l=0.6u
XM3 n2 n3 n1 VSUBS nfet_05v0 w=0.395u l=0.6u
XM4 n4 n5 n2 VSUBS nfet_05v0 w=0.395u l=0.6u
XM5 VSS n6 n4 VSUBS nfet_05v0 w=0.395u l=0.6u
XM6 n6 n2 VSS VSUBS nfet_05v0 w=0.395u l=0.6u
XM7 VSS n3 n5 VSUBS nfet_05v0 w=0.39u l=0.6u
XM8 n3 CLK VSS VSUBS nfet_05v0 w=0.39u l=0.6u
XM9 n7 CLK n8 VSUBS nfet_05v0 w=0.39u l=0.6u
XM10 VSS n6 n7 VSUBS nfet_05v0 w=0.39u l=0.6u
XM11 Q n8 VSS VSUBS nfet_05v0 w=0.63u l=0.6u
XM12 n9 TE VDD VNW pfet_05v0 w=0.925u l=0.5u
XM13 n10 E n9 VNW pfet_05v0 w=0.925u l=0.5u
XM14 n2 n5 n10 VNW pfet_05v0 w=0.765u l=0.5u
XM15 n11 n3 n2 VNW pfet_05v0 w=0.765u l=0.5u
XM16 VDD n6 n11 VNW pfet_05v0 w=0.765u l=0.5u
XM17 n6 n2 VDD VNW pfet_05v0 w=0.765u l=0.5u
XM18 VDD n3 n5 VNW pfet_05v0 w=0.92u l=0.5u
XM19 n3 CLK VDD VNW pfet_05v0 w=0.92u l=0.5u
XM20 n8 CLK VDD VNW pfet_05v0 w=0.92u l=0.5u
XM21 VDD n6 n8 VNW pfet_05v0 w=0.92u l=0.5u
XM22 Q n8 VDD VNW pfet_05v0 w=1.22u l=0.5u
.ends

# Layout, gdstk code
import gdstk
lib = gdstk.Library(unit=1e-6, precision=1e-09)
def R(c, l, rs):  # rectangles x0, y0, x1, y1
    for r in rs: c.add(gdstk.rectangle(r[:2], r[2:], *l))
def A(c, l, x, y, w, h, nx, ny, dx, dy):  # array of equal rectangles
    R(c, l, [(x+i*dx, y+j*dy, x+i*dx+w, y+j*dy+h) for i in range(nx) for j in range(ny)])
def P(c, l, *ps):  # polygons
    for p in ps: c.add(gdstk.Polygon(p, *l))
boundary = (0, 0)
nwell = (21, 0)
comp = (22, 0)
poly2 = (30, 0)
pplus = (31, 0)
nplus = (32, 0)
contact = (33, 0)
metal1 = (34, 0)
dualgate = (55, 0)
v5_xtor = (112, 1)
lvpwell = (204, 0)

gf180mcu_fd_sc_mcu7t5v0_ = lib.new_cell('gf180mcu_fd_sc_mcu7t5v0__icgtp_1')
R(gf180mcu_fd_sc_mcu7t5v0_, boundary, [(0,0,15.68,3.92)])
P(gf180mcu_fd_sc_mcu7t5v0_, nwell, [(-0.43,1.76),(-0.43,4.35),(16.11,4.35),(16.11,1.76),(7.75,1.76),(7.75,1.775),(4.76,1.775),(4.76,1.76)])
R(gf180mcu_fd_sc_mcu7t5v0_, comp, [(8.635,0.455,11.235,0.845), (8.605,2.375,11.01,3.295)])
P(gf180mcu_fd_sc_mcu7t5v0_, comp, [(0.18,0.685),(0.18,1.08),(4.895,1.08),(4.895,1.175),(7.615,1.175),(7.615,0.78),(4.995,0.78),(4.995,0.685)],
  [(0.28,2.375),(0.28,3.3),(5.335,3.3),(5.335,3.14),(7.615,3.14),(7.615,2.375),(5.235,2.375),(5.235,2.535),(2.64,2.535),(2.64,2.375)],
  [(11.57,2.36),(11.57,3.28),(13.855,3.28),(13.855,3.58),(15.195,3.58),(15.195,2.36)],
  [(11.595,0.455),(11.595,0.845),(13.855,0.845),(13.855,1.085),(15.295,1.085),(15.295,0.455)])
P(gf180mcu_fd_sc_mcu7t5v0_, poly2, [(0.62,0.465),(0.62,1.3),(0.72,1.3),(0.72,3.52),(1.22,3.52),(1.22,0.465)],
  [(1.74,0.465),(1.74,3.52),(2.24,3.52),(2.24,1.3),(2.34,1.3),(2.34,0.465)],
  [(2.86,0.465),(2.86,1.795),(3.755,1.795),(3.755,1.435),(3.46,1.435),(3.46,0.465)],
  [(5.295,0.56),(5.295,1.395),(5.635,1.395),(5.635,3.36),(6.135,3.36),(6.135,1.74),(5.895,1.74),(5.895,0.56)],
  [(6.575,0.56),(6.575,1.395),(6.675,1.395),(6.675,3.36),(7.175,3.36),(7.175,0.56)],
  [(3.995,0.12),(3.995,2.035),(2.94,2.035),(2.94,3.52),(3.44,3.52),(3.44,2.235),(4.195,2.235),(4.195,1.3),(4.595,1.3),(4.595,0.32),(7.915,0.32),(7.915,0.825),(8.275,0.825),(8.275,0.12)],
  [(9.075,0.23),(9.075,1.145),(9.045,1.145),(9.045,3.6),(4.935,3.6),(4.935,1.805),(4.435,1.805),(4.435,3.8),(9.545,3.8),(9.545,1.07),(9.675,1.07),(9.675,0.23)],
  [(10.195,0.23),(10.195,1.145),(10.07,1.145),(10.07,3.53),(10.57,3.53),(10.57,1.07),(10.795,1.07),(10.795,0.23)],
  [(12.035,0.235),(12.035,3.515),(12.535,3.515),(12.535,1.065),(12.635,1.065),(12.635,0.235)],
  [(12.955,0.235),(12.955,1.065),(13.055,1.065),(13.055,3.515),(13.555,3.515),(13.555,0.235)],
  [(14.255,0.22),(14.255,3.8),(14.755,3.8),(14.755,1.44),(14.855,1.44),(14.855,0.22)])
P(gf180mcu_fd_sc_mcu7t5v0_, pplus, [(-0.2,1.76),(-0.2,4.12),(15.88,4.12),(15.88,1.76),(7.75,1.76),(7.75,1.775),(4.76,1.775),(4.76,1.76)])
P(gf180mcu_fd_sc_mcu7t5v0_, nplus, [(-0.2,-0.2),(-0.2,1.76),(4.76,1.76),(4.76,1.775),(7.75,1.775),(7.75,1.76),(15.88,1.76),(15.88,-0.2)])
A(gf180mcu_fd_sc_mcu7t5v0_, contact, 8.705, 0.535, 0.22, 0.22, 3, 1, 1.12, 0)
A(gf180mcu_fd_sc_mcu7t5v0_, contact, 0.25, 0.77, 0.22, 0.22, 4, 1, 1.12, 0)
R(gf180mcu_fd_sc_mcu7t5v0_, contact, [(13.705,0.525,13.925,0.745), (7.985,0.535,8.205,0.755), (11.665,0.535,11.885,0.755), (15.005,0.72,15.225,0.94), (6.125,0.85,6.345,1.07), (7.325,0.85,7.545,1.07), (9.255,1.205,9.475,1.425), (12.13,1.29,12.35,1.51), (6.78,1.345,7,1.565), (3.465,1.505,3.685,1.725), (10.275,1.54,10.495,1.76), (14.325,1.745,14.545,1.965), (5.755,1.81,5.975,2.03), (9.255,1.83,9.475,2.05), (0.8,1.85,1.02,2.07), (1.94,1.85,2.16,2.07), (4.57,1.875,4.79,2.095), (13.135,1.97,13.355,2.19), (14.905,2.43,15.125,2.65), (7.325,2.495,7.545,2.715), (12.685,2.5,12.905,2.72), (11.64,2.52,11.86,2.74), (0.35,2.54,0.57,2.76), (8.675,2.57,8.895,2.79), (10.72,2.57,10.94,2.79), (3.815,2.845,4.035,3.065), (6.305,2.85,6.525,3.07), (14.905,2.9,15.125,3.12), (12.685,2.97,12.905,3.19), (13.705,2.975,13.925,3.195), (9.695,2.98,9.915,3.2), (11.64,2.99,11.86,3.21), (0.35,3.01,0.57,3.23)])
R(gf180mcu_fd_sc_mcu7t5v0_, metal1, [(0.29,1.77,1.59,2.15)])
P(gf180mcu_fd_sc_mcu7t5v0_, metal1, [(1.865,1.77),(1.865,2.15),(2.34,2.15),(2.34,3.37),(2.75,3.37),(2.75,1.77)],
  [(0.19,0.765),(0.19,1.46),(2.115,1.46),(2.115,0.995),(2.77,0.995),(2.77,0.765),(1.885,0.765),(1.885,1.225),(0.53,1.225),(0.53,0.765)],
  [(3.46,1.445),(3.46,2.1),(4.935,2.1),(4.935,1.87),(3.69,1.87),(3.69,1.445)],
  [(3,0.765),(3,2.56),(3.81,2.56),(3.81,3.125),(4.04,3.125),(4.04,2.56),(5.435,2.56),(5.435,1.575),(7.08,1.575),(7.08,1.34),(5.205,1.34),(5.205,2.33),(3.23,2.33),(3.23,0.995),(3.89,0.995),(3.89,0.765)],
  [(7.915,0.53),(7.915,2.035),(8.645,2.035),(8.645,2.85),(8.93,2.85),(8.93,1.805),(8.275,1.805),(8.275,0.76),(9.075,0.76),(9.075,0.53)],
  [(10.28,0.53),(10.28,1.075),(9.245,1.075),(9.245,2.225),(10.715,2.225),(10.715,2.85),(10.945,2.85),(10.945,1.995),(9.485,1.995),(9.485,1.305),(10.51,1.305),(10.51,0.76),(11.235,0.76),(11.235,0.53)],
  [(10.785,1.21),(10.785,1.535),(10.215,1.535),(10.215,1.765),(11.065,1.765),(11.065,1.59),(12.755,1.59),(12.755,1.21)],
  [(7.32,0.78),(7.32,1.805),(5.685,1.805),(5.685,2.035),(7.32,2.035),(7.32,3.39),(9.395,3.39),(9.395,2.69),(10.2,2.69),(10.2,3.39),(11.405,3.39),(11.405,2.225),(12.265,2.225),(12.265,2.21),(13.415,2.21),(13.415,1.965),(12.01,1.965),(12.01,1.995),(11.175,1.995),(11.175,3.16),(10.43,3.16),(10.43,2.455),(9.165,2.455),(9.165,3.16),(7.55,3.16),(7.55,0.78)],
  [(11.595,0.53),(11.595,0.76),(13.01,0.76),(13.01,1.535),(13.645,1.535),(13.645,2.44),(12.68,2.44),(12.68,3.25),(12.91,3.25),(12.91,2.67),(13.875,2.67),(13.875,2.025),(14.55,2.025),(14.55,1.685),(13.875,1.685),(13.875,1.265),(13.24,1.265),(13.24,0.53)],
  [(14.7,0.56),(14.7,1.12),(14.78,1.12),(14.78,2.33),(14.16,2.33),(14.16,3.27),(15.23,3.27),(15.23,0.56)],
  [(0,-0.3),(0,0.3),(1.31,0.3),(1.31,0.995),(1.65,0.995),(1.65,0.3),(6.065,0.3),(6.065,1.075),(6.405,1.075),(6.405,0.3),(9.82,0.3),(9.82,0.845),(10.05,0.845),(10.05,0.3),(13.7,0.3),(13.7,0.805),(13.93,0.805),(13.93,0.3),(15.68,0.3),(15.68,-0.3)],
  [(11.635,2.46),(11.635,3.62),(9.92,3.62),(9.92,2.92),(9.69,2.92),(9.69,3.62),(6.585,3.62),(6.585,2.845),(6.245,2.845),(6.245,3.62),(0.575,3.62),(0.575,2.48),(0.345,2.48),(0.345,3.62),(0,3.62),(0,4.22),(15.68,4.22),(15.68,3.62),(13.93,3.62),(13.93,2.9),(13.7,2.9),(13.7,3.62),(11.865,3.62),(11.865,2.46)])
R(gf180mcu_fd_sc_mcu7t5v0_, dualgate, [(-0.28,-0.28,15.96,4.2)])
R(gf180mcu_fd_sc_mcu7t5v0_, v5_xtor, [(0,0,15.68,3.92)])
P(gf180mcu_fd_sc_mcu7t5v0_, lvpwell, [(-0.43,-0.43),(-0.43,1.76),(4.76,1.76),(4.76,1.775),(7.75,1.775),(7.75,1.76),(16.11,1.76),(16.11,-0.43)])
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('Q', (14.84,2.52), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('TE', (0.84,1.96), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VDD', (8.68,3.92), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VSS', (8.68,0), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('CLK', (11.48,1.4), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('E', (2.52,2.52), layer=34, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Vendor GLOBALFOUNDRIES', (0,2), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Product GF018hv5v_mcu_sc7', (0,1.5), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Version 2015q2v1', (0,1), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('& Metric 1.00', (0,0.5), layer=63, texttype=63))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VNW', (0.345,3.92), layer=21, texttype=10))
gf180mcu_fd_sc_mcu7t5v0_.add(gdstk.Label('VPW', (0.34,-0.085), layer=204, texttype=10))

lib.write_gds('gf180mcu_fd_sc_mcu7t5v0__icgtp_1.gds')
